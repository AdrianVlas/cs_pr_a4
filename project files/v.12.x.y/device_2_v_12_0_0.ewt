<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Flash-Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>4</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package checked="true" name="STDCHECKS">
            <group checked="true" name="ARR">
              <check checked="true" name="ARR-inv-index-pos"/>
              <check checked="true" name="ARR-inv-index-ptr-pos"/>
              <check checked="true" name="ARR-inv-index-ptr"/>
              <check checked="true" name="ARR-inv-index"/>
              <check checked="true" name="ARR-neg-index"/>
              <check checked="true" name="ARR-uninit-index"/>
            </group>
            <group checked="true" name="ATH">
              <check checked="true" name="ATH-cmp-float"/>
              <check checked="true" name="ATH-cmp-unsign-neg"/>
              <check checked="true" name="ATH-cmp-unsign-pos"/>
              <check checked="true" name="ATH-div-0-assign"/>
              <check checked="true" name="ATH-div-0-cmp-aft"/>
              <check checked="true" name="ATH-div-0-cmp-bef"/>
              <check checked="true" name="ATH-div-0-interval"/>
              <check checked="true" name="ATH-div-0-pos"/>
              <check checked="true" name="ATH-div-0-unchk-global"/>
              <check checked="true" name="ATH-div-0-unchk-local"/>
              <check checked="true" name="ATH-div-0-unchk-param"/>
              <check checked="true" name="ATH-div-0"/>
              <check checked="true" name="ATH-inc-bool"/>
              <check checked="true" name="ATH-malloc-overrun"/>
              <check checked="true" name="ATH-neg-check-nonneg"/>
              <check checked="true" name="ATH-neg-check-pos"/>
              <check checked="true" name="ATH-new-overrun"/>
              <check checked="false" name="ATH-overflow-cast"/>
              <check checked="true" name="ATH-overflow"/>
              <check checked="true" name="ATH-shift-bounds"/>
              <check checked="true" name="ATH-shift-neg"/>
              <check checked="true" name="ATH-sizeof-by-sizeof"/>
            </group>
            <group checked="true" name="CAST">
              <check checked="false" name="CAST-old-style"/>
            </group>
            <group checked="true" name="CATCH">
              <check checked="true" name="CATCH-object-slicing"/>
              <check checked="false" name="CATCH-xtor-bad-member"/>
            </group>
            <group checked="true" name="COMMA">
              <check checked="false" name="COMMA-overload"/>
            </group>
            <group checked="true" name="COMMENT">
              <check checked="true" name="COMMENT-nested"/>
            </group>
            <group checked="false" name="CONCURRENCY">
              <check checked="true" name="CONCURRENCY-double-lock"/>
              <check checked="true" name="CONCURRENCY-double-unlock"/>
              <check checked="true" name="CONCURRENCY-lock-no-unlock"/>
              <check checked="true" name="CONCURRENCY-sleep-while-locking"/>
            </group>
            <group checked="true" name="CONST">
              <check checked="false" name="CONST-local"/>
              <check checked="true" name="CONST-member-ret"/>
              <check checked="false" name="CONST-param"/>
            </group>
            <group checked="true" name="COP">
              <check checked="true" name="COP-alloc-ctor"/>
              <check checked="true" name="COP-assign-op-ret"/>
              <check checked="true" name="COP-assign-op-self"/>
              <check checked="true" name="COP-assign-op"/>
              <check checked="true" name="COP-copy-ctor"/>
              <check checked="true" name="COP-dealloc-dtor"/>
              <check checked="true" name="COP-dtor-throw"/>
              <check checked="true" name="COP-dtor"/>
              <check checked="true" name="COP-init-order"/>
              <check checked="true" name="COP-init-uninit"/>
              <check checked="true" name="COP-member-uninit"/>
            </group>
            <group checked="true" name="CPU">
              <check checked="true" name="CPU-ctor-call-virt"/>
              <check checked="false" name="CPU-ctor-implicit"/>
              <check checked="true" name="CPU-delete-throw"/>
              <check checked="true" name="CPU-delete-void"/>
              <check checked="true" name="CPU-dtor-call-virt"/>
              <check checked="true" name="CPU-malloc-class"/>
              <check checked="true" name="CPU-nonvirt-dtor"/>
              <check checked="true" name="CPU-return-ref-to-class-data"/>
            </group>
            <group checked="true" name="DECL">
              <check checked="false" name="DECL-implicit-int"/>
            </group>
            <group checked="true" name="DEFINE">
              <check checked="true" name="DEFINE-hash-multiple"/>
            </group>
            <group checked="true" name="ENUM">
              <check checked="false" name="ENUM-bounds"/>
            </group>
            <group checked="true" name="EXP">
              <check checked="true" name="EXP-cond-assign"/>
              <check checked="true" name="EXP-dangling-else"/>
              <check checked="true" name="EXP-loop-exit"/>
              <check checked="false" name="EXP-main-ret-int"/>
              <check checked="false" name="EXP-null-stmt"/>
              <check checked="false" name="EXP-stray-semicolon"/>
            </group>
            <group checked="true" name="EXPR">
              <check checked="true" name="EXPR-const-overflow"/>
            </group>
            <group checked="false" name="FPT">
              <check checked="true" name="FPT-arith-address"/>
              <check checked="true" name="FPT-arith"/>
              <check checked="true" name="FPT-cmp-null"/>
              <check checked="false" name="FPT-literal"/>
              <check checked="true" name="FPT-misuse"/>
            </group>
            <group checked="true" name="FUNC">
              <check checked="false" name="FUNC-implicit-decl"/>
              <check checked="false" name="FUNC-unprototyped-all"/>
              <check checked="true" name="FUNC-unprototyped-used"/>
            </group>
            <group checked="true" name="INCLUDE">
              <check checked="false" name="INCLUDE-c-file"/>
            </group>
            <group checked="true" name="INT">
              <check checked="false" name="INT-use-signed-as-unsigned-pos"/>
              <check checked="true" name="INT-use-signed-as-unsigned"/>
            </group>
            <group checked="true" name="ITR">
              <check checked="true" name="ITR-end-cmp-aft"/>
              <check checked="true" name="ITR-end-cmp-bef"/>
              <check checked="true" name="ITR-invalidated"/>
              <check checked="true" name="ITR-mismatch-alg"/>
              <check checked="true" name="ITR-store"/>
              <check checked="true" name="ITR-uninit"/>
            </group>
            <group checked="true" name="LIB">
              <check checked="false" name="LIB-bsearch-overrun-pos"/>
              <check checked="false" name="LIB-bsearch-overrun"/>
              <check checked="false" name="LIB-buf-size"/>
              <check checked="false" name="LIB-fn-unsafe"/>
              <check checked="false" name="LIB-fread-overrun-pos"/>
              <check checked="true" name="LIB-fread-overrun"/>
              <check checked="false" name="LIB-memchr-overrun-pos"/>
              <check checked="true" name="LIB-memchr-overrun"/>
              <check checked="false" name="LIB-memcpy-overrun-pos"/>
              <check checked="true" name="LIB-memcpy-overrun"/>
              <check checked="false" name="LIB-memset-overrun-pos"/>
              <check checked="true" name="LIB-memset-overrun"/>
              <check checked="false" name="LIB-putenv"/>
              <check checked="false" name="LIB-qsort-overrun-pos"/>
              <check checked="false" name="LIB-qsort-overrun"/>
              <check checked="true" name="LIB-return-const"/>
              <check checked="true" name="LIB-return-error"/>
              <check checked="true" name="LIB-return-leak"/>
              <check checked="true" name="LIB-return-neg"/>
              <check checked="true" name="LIB-return-null"/>
              <check checked="false" name="LIB-sprintf-overrun"/>
              <check checked="false" name="LIB-std-sort-overrun-pos"/>
              <check checked="true" name="LIB-std-sort-overrun"/>
              <check checked="false" name="LIB-strcat-overrun-pos"/>
              <check checked="true" name="LIB-strcat-overrun"/>
              <check checked="false" name="LIB-strcpy-overrun-pos"/>
              <check checked="true" name="LIB-strcpy-overrun"/>
              <check checked="false" name="LIB-strncat-overrun-pos"/>
              <check checked="true" name="LIB-strncat-overrun"/>
              <check checked="false" name="LIB-strncmp-overrun-pos"/>
              <check checked="true" name="LIB-strncmp-overrun"/>
              <check checked="false" name="LIB-strncpy-overrun-pos"/>
              <check checked="true" name="LIB-strncpy-overrun"/>
            </group>
            <group checked="true" name="LOGIC">
              <check checked="false" name="LOGIC-overload"/>
            </group>
            <group checked="false" name="MEM">
              <check checked="true" name="MEM-alias-double-free"/>
              <check checked="true" name="MEM-delete-array-op"/>
              <check checked="true" name="MEM-delete-op"/>
              <check checked="true" name="MEM-double-free-alias"/>
              <check checked="true" name="MEM-double-free-some"/>
              <check checked="true" name="MEM-double-free"/>
              <check checked="true" name="MEM-free-field"/>
              <check checked="true" name="MEM-free-fptr"/>
              <check checked="false" name="MEM-free-no-alloc-struct"/>
              <check checked="true" name="MEM-free-no-alloc"/>
              <check checked="true" name="MEM-free-no-use"/>
              <check checked="true" name="MEM-free-op"/>
              <check checked="true" name="MEM-free-struct-field"/>
              <check checked="true" name="MEM-free-variable-alias"/>
              <check checked="true" name="MEM-free-variable"/>
              <check checked="true" name="MEM-leak-alias"/>
              <check checked="false" name="MEM-leak"/>
              <check checked="false" name="MEM-malloc-arith"/>
              <check checked="true" name="MEM-malloc-diff-type"/>
              <check checked="true" name="MEM-malloc-sizeof-ptr"/>
              <check checked="true" name="MEM-malloc-sizeof"/>
              <check checked="false" name="MEM-malloc-strlen"/>
              <check checked="true" name="MEM-realloc-diff-type"/>
              <check checked="true" name="MEM-return-free"/>
              <check checked="true" name="MEM-return-no-assign"/>
              <check checked="true" name="MEM-stack-alias"/>
              <check checked="true" name="MEM-stack-global-alias"/>
              <check checked="true" name="MEM-stack-global-field"/>
              <check checked="true" name="MEM-stack-global"/>
              <check checked="true" name="MEM-stack-param-ref"/>
              <check checked="true" name="MEM-stack-param"/>
              <check checked="true" name="MEM-stack-pos"/>
              <check checked="true" name="MEM-stack-ref"/>
              <check checked="true" name="MEM-stack"/>
              <check checked="true" name="MEM-use-free-all"/>
              <check checked="true" name="MEM-use-free-some"/>
            </group>
            <group checked="false" name="POR">
              <check checked="true" name="POR-imp-cast-subscript"/>
              <check checked="false" name="POR-imp-cast-ternary"/>
            </group>
            <group checked="true" name="PTR">
              <check checked="true" name="PTR-arith-field"/>
              <check checked="true" name="PTR-arith-stack"/>
              <check checked="true" name="PTR-arith-var"/>
              <check checked="true" name="PTR-cmp-str-lit"/>
              <check checked="true" name="PTR-null-assign-fun-pos"/>
              <check checked="true" name="PTR-null-assign-pos"/>
              <check checked="true" name="PTR-null-assign"/>
              <check checked="true" name="PTR-null-cmp-aft"/>
              <check checked="true" name="PTR-null-cmp-bef-fun"/>
              <check checked="true" name="PTR-null-cmp-bef"/>
              <check checked="true" name="PTR-null-fun-pos"/>
              <check checked="true" name="PTR-null-literal-pos"/>
              <check checked="false" name="PTR-overload"/>
              <check checked="true" name="PTR-singleton-arith-pos"/>
              <check checked="true" name="PTR-singleton-arith"/>
              <check checked="true" name="PTR-unchk-param-some"/>
              <check checked="false" name="PTR-unchk-param"/>
              <check checked="true" name="PTR-uninit-pos"/>
              <check checked="true" name="PTR-uninit"/>
            </group>
            <group checked="true" name="RED">
              <check checked="false" name="RED-case-reach"/>
              <check checked="false" name="RED-cmp-always"/>
              <check checked="false" name="RED-cmp-never"/>
              <check checked="false" name="RED-cond-always"/>
              <check checked="true" name="RED-cond-const-assign"/>
              <check checked="false" name="RED-cond-const-expr"/>
              <check checked="false" name="RED-cond-const"/>
              <check checked="false" name="RED-cond-never"/>
              <check checked="true" name="RED-dead"/>
              <check checked="false" name="RED-expr"/>
              <check checked="false" name="RED-func-no-effect"/>
              <check checked="true" name="RED-local-hides-global"/>
              <check checked="true" name="RED-local-hides-local"/>
              <check checked="true" name="RED-local-hides-member"/>
              <check checked="true" name="RED-local-hides-param"/>
              <check checked="false" name="RED-no-effect"/>
              <check checked="true" name="RED-self-assign"/>
              <check checked="true" name="RED-unused-assign"/>
              <check checked="false" name="RED-unused-param"/>
              <check checked="false" name="RED-unused-return-val"/>
              <check checked="false" name="RED-unused-val"/>
              <check checked="true" name="RED-unused-var-all"/>
            </group>
            <group checked="true" name="RESOURCE">
              <check checked="false" name="RESOURCE-deref-file"/>
              <check checked="true" name="RESOURCE-double-close"/>
              <check checked="true" name="RESOURCE-file-no-close-all"/>
              <check checked="false" name="RESOURCE-file-pos-neg"/>
              <check checked="true" name="RESOURCE-file-use-after-close"/>
              <check checked="false" name="RESOURCE-implicit-deref-file"/>
              <check checked="true" name="RESOURCE-write-ronly-file"/>
            </group>
            <group checked="false" name="SEM">
              <check checked="false" name="SEM-const-call"/>
              <check checked="false" name="SEM-const-global"/>
              <check checked="false" name="SEM-pure-call"/>
              <check checked="false" name="SEM-pure-global"/>
            </group>
            <group checked="true" name="SIZEOF">
              <check checked="true" name="SIZEOF-side-effect"/>
            </group>
            <group checked="true" name="SPC">
              <check checked="false" name="SPC-init-list"/>
              <check checked="true" name="SPC-order"/>
              <check checked="true" name="SPC-return"/>
              <check checked="true" name="SPC-uninit-arr-all"/>
              <check checked="true" name="SPC-uninit-struct-field-heap"/>
              <check checked="true" name="SPC-uninit-struct-field"/>
              <check checked="true" name="SPC-uninit-struct"/>
              <check checked="true" name="SPC-uninit-var-all"/>
              <check checked="true" name="SPC-uninit-var-some"/>
              <check checked="false" name="SPC-volatile-reads"/>
              <check checked="false" name="SPC-volatile-writes"/>
            </group>
            <group checked="true" name="STR">
              <check checked="true" name="STR-trigraph"/>
            </group>
            <group checked="true" name="STRUCT">
              <check checked="false" name="STRUCT-signed-bit"/>
            </group>
            <group checked="true" name="SWITCH">
              <check checked="true" name="SWITCH-fall-through"/>
            </group>
            <group checked="true" name="THROW">
              <check checked="false" name="THROW-empty"/>
              <check checked="false" name="THROW-main"/>
              <check checked="true" name="THROW-null"/>
              <check checked="true" name="THROW-ptr"/>
              <check checked="true" name="THROW-static"/>
              <check checked="true" name="THROW-unhandled"/>
            </group>
            <group checked="true" name="UNION">
              <check checked="true" name="UNION-overlap-assign"/>
              <check checked="true" name="UNION-type-punning"/>
            </group>
          </package>
          <package checked="false" name="MISRAC2004">
            <group checked="false" name="MISRAC2004-1">
              <check checked="true" name="MISRAC2004-1.1"/>
              <check checked="true" name="MISRAC2004-1.2_a"/>
              <check checked="true" name="MISRAC2004-1.2_b"/>
              <check checked="true" name="MISRAC2004-1.2_c"/>
              <check checked="true" name="MISRAC2004-1.2_d"/>
              <check checked="true" name="MISRAC2004-1.2_e"/>
              <check checked="true" name="MISRAC2004-1.2_f"/>
              <check checked="true" name="MISRAC2004-1.2_g"/>
              <check checked="true" name="MISRAC2004-1.2_h"/>
              <check checked="true" name="MISRAC2004-1.2_i"/>
              <check checked="true" name="MISRAC2004-1.2_j"/>
            </group>
            <group checked="true" name="MISRAC2004-2">
              <check checked="true" name="MISRAC2004-2.1"/>
              <check checked="true" name="MISRAC2004-2.2"/>
              <check checked="true" name="MISRAC2004-2.3"/>
              <check checked="false" name="MISRAC2004-2.4"/>
            </group>
            <group checked="true" name="MISRAC2004-4">
              <check checked="true" name="MISRAC2004-4.2"/>
            </group>
            <group checked="true" name="MISRAC2004-5">
              <check checked="true" name="MISRAC2004-5.2_a"/>
              <check checked="true" name="MISRAC2004-5.2_b"/>
              <check checked="true" name="MISRAC2004-5.2_c"/>
              <check checked="true" name="MISRAC2004-5.3"/>
              <check checked="true" name="MISRAC2004-5.4"/>
              <check checked="false" name="MISRAC2004-5.5"/>
            </group>
            <group checked="true" name="MISRAC2004-6">
              <check checked="true" name="MISRAC2004-6.1"/>
              <check checked="false" name="MISRAC2004-6.3"/>
              <check checked="true" name="MISRAC2004-6.4"/>
              <check checked="true" name="MISRAC2004-6.5"/>
            </group>
            <group checked="true" name="MISRAC2004-7">
              <check checked="true" name="MISRAC2004-7.1"/>
            </group>
            <group checked="true" name="MISRAC2004-8">
              <check checked="true" name="MISRAC2004-8.1"/>
              <check checked="true" name="MISRAC2004-8.2"/>
              <check checked="true" name="MISRAC2004-8.5_a"/>
              <check checked="true" name="MISRAC2004-8.5_b"/>
              <check checked="true" name="MISRAC2004-8.12"/>
            </group>
            <group checked="true" name="MISRAC2004-9">
              <check checked="true" name="MISRAC2004-9.1_a"/>
              <check checked="true" name="MISRAC2004-9.1_b"/>
              <check checked="true" name="MISRAC2004-9.1_c"/>
              <check checked="true" name="MISRAC2004-9.2"/>
            </group>
            <group checked="true" name="MISRAC2004-10">
              <check checked="true" name="MISRAC2004-10.1_a"/>
              <check checked="true" name="MISRAC2004-10.1_b"/>
              <check checked="true" name="MISRAC2004-10.1_c"/>
              <check checked="true" name="MISRAC2004-10.1_d"/>
              <check checked="true" name="MISRAC2004-10.2_a"/>
              <check checked="true" name="MISRAC2004-10.2_b"/>
              <check checked="true" name="MISRAC2004-10.2_c"/>
              <check checked="true" name="MISRAC2004-10.2_d"/>
              <check checked="true" name="MISRAC2004-10.3"/>
              <check checked="true" name="MISRAC2004-10.4"/>
              <check checked="true" name="MISRAC2004-10.5"/>
              <check checked="true" name="MISRAC2004-10.6"/>
            </group>
            <group checked="true" name="MISRAC2004-11">
              <check checked="true" name="MISRAC2004-11.1"/>
              <check checked="false" name="MISRAC2004-11.3"/>
              <check checked="false" name="MISRAC2004-11.4"/>
              <check checked="true" name="MISRAC2004-11.5"/>
            </group>
            <group checked="true" name="MISRAC2004-12">
              <check checked="false" name="MISRAC2004-12.1"/>
              <check checked="true" name="MISRAC2004-12.2_a"/>
              <check checked="true" name="MISRAC2004-12.2_b"/>
              <check checked="true" name="MISRAC2004-12.2_c"/>
              <check checked="true" name="MISRAC2004-12.3"/>
              <check checked="true" name="MISRAC2004-12.4"/>
              <check checked="false" name="MISRAC2004-12.6_a"/>
              <check checked="false" name="MISRAC2004-12.6_b"/>
              <check checked="true" name="MISRAC2004-12.7"/>
              <check checked="true" name="MISRAC2004-12.8"/>
              <check checked="true" name="MISRAC2004-12.9"/>
              <check checked="true" name="MISRAC2004-12.10"/>
              <check checked="false" name="MISRAC2004-12.11"/>
              <check checked="true" name="MISRAC2004-12.12_a"/>
              <check checked="true" name="MISRAC2004-12.12_b"/>
              <check checked="false" name="MISRAC2004-12.13"/>
            </group>
            <group checked="true" name="MISRAC2004-13">
              <check checked="true" name="MISRAC2004-13.1"/>
              <check checked="false" name="MISRAC2004-13.2_a"/>
              <check checked="false" name="MISRAC2004-13.2_b"/>
              <check checked="false" name="MISRAC2004-13.2_c"/>
              <check checked="false" name="MISRAC2004-13.2_d"/>
              <check checked="false" name="MISRAC2004-13.2_e"/>
              <check checked="true" name="MISRAC2004-13.3"/>
              <check checked="true" name="MISRAC2004-13.4"/>
              <check checked="true" name="MISRAC2004-13.5"/>
              <check checked="true" name="MISRAC2004-13.6"/>
              <check checked="true" name="MISRAC2004-13.7_a"/>
              <check checked="true" name="MISRAC2004-13.7_b"/>
            </group>
            <group checked="true" name="MISRAC2004-14">
              <check checked="true" name="MISRAC2004-14.1"/>
              <check checked="true" name="MISRAC2004-14.2"/>
              <check checked="true" name="MISRAC2004-14.3"/>
              <check checked="true" name="MISRAC2004-14.4"/>
              <check checked="true" name="MISRAC2004-14.5"/>
              <check checked="true" name="MISRAC2004-14.6"/>
              <check checked="true" name="MISRAC2004-14.7"/>
              <check checked="true" name="MISRAC2004-14.8_a"/>
              <check checked="true" name="MISRAC2004-14.8_b"/>
              <check checked="true" name="MISRAC2004-14.8_c"/>
              <check checked="true" name="MISRAC2004-14.8_d"/>
              <check checked="true" name="MISRAC2004-14.9"/>
              <check checked="true" name="MISRAC2004-14.10"/>
            </group>
            <group checked="true" name="MISRAC2004-15">
              <check checked="true" name="MISRAC2004-15.0"/>
              <check checked="true" name="MISRAC2004-15.1"/>
              <check checked="true" name="MISRAC2004-15.2"/>
              <check checked="true" name="MISRAC2004-15.3"/>
              <check checked="true" name="MISRAC2004-15.4"/>
              <check checked="true" name="MISRAC2004-15.5"/>
            </group>
            <group checked="true" name="MISRAC2004-16">
              <check checked="true" name="MISRAC2004-16.1"/>
              <check checked="true" name="MISRAC2004-16.2_a"/>
              <check checked="true" name="MISRAC2004-16.2_b"/>
              <check checked="true" name="MISRAC2004-16.3"/>
              <check checked="true" name="MISRAC2004-16.5"/>
              <check checked="true" name="MISRAC2004-16.7"/>
              <check checked="true" name="MISRAC2004-16.8"/>
              <check checked="true" name="MISRAC2004-16.9"/>
              <check checked="true" name="MISRAC2004-16.10"/>
            </group>
            <group checked="true" name="MISRAC2004-17">
              <check checked="true" name="MISRAC2004-17.1_a"/>
              <check checked="true" name="MISRAC2004-17.1_b"/>
              <check checked="true" name="MISRAC2004-17.1_c"/>
              <check checked="true" name="MISRAC2004-17.4_a"/>
              <check checked="true" name="MISRAC2004-17.4_b"/>
              <check checked="true" name="MISRAC2004-17.5"/>
              <check checked="true" name="MISRAC2004-17.6_a"/>
              <check checked="true" name="MISRAC2004-17.6_b"/>
              <check checked="true" name="MISRAC2004-17.6_c"/>
              <check checked="true" name="MISRAC2004-17.6_d"/>
            </group>
            <group checked="true" name="MISRAC2004-18">
              <check checked="true" name="MISRAC2004-18.1"/>
              <check checked="true" name="MISRAC2004-18.2"/>
              <check checked="true" name="MISRAC2004-18.4"/>
            </group>
            <group checked="true" name="MISRAC2004-19">
              <check checked="false" name="MISRAC2004-19.2"/>
              <check checked="true" name="MISRAC2004-19.6"/>
              <check checked="false" name="MISRAC2004-19.7"/>
              <check checked="true" name="MISRAC2004-19.12"/>
              <check checked="false" name="MISRAC2004-19.13"/>
              <check checked="true" name="MISRAC2004-19.15"/>
            </group>
            <group checked="true" name="MISRAC2004-20">
              <check checked="true" name="MISRAC2004-20.1"/>
              <check checked="true" name="MISRAC2004-20.4"/>
              <check checked="true" name="MISRAC2004-20.5"/>
              <check checked="true" name="MISRAC2004-20.6"/>
              <check checked="true" name="MISRAC2004-20.7"/>
              <check checked="true" name="MISRAC2004-20.8"/>
              <check checked="true" name="MISRAC2004-20.9"/>
              <check checked="true" name="MISRAC2004-20.10"/>
              <check checked="true" name="MISRAC2004-20.11"/>
              <check checked="true" name="MISRAC2004-20.12"/>
            </group>
          </package>
          <package checked="false" name="MISRAC2012">
            <group checked="true" name="MISRAC2012-Dir-4">
              <check checked="true" name="MISRAC2012-Dir-4.3"/>
              <check checked="false" name="MISRAC2012-Dir-4.4"/>
              <check checked="false" name="MISRAC2012-Dir-4.6_a"/>
              <check checked="false" name="MISRAC2012-Dir-4.6_b"/>
              <check checked="false" name="MISRAC2012-Dir-4.9"/>
              <check checked="true" name="MISRAC2012-Dir-4.10"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-1">
              <check checked="true" name="MISRAC2012-Rule-1.3_a"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_b"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_c"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_d"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_e"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_f"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_g"/>
              <check checked="true" name="MISRAC2012-Rule-1.3_h"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-2">
              <check checked="true" name="MISRAC2012-Rule-2.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-2.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-2.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-2.2_c"/>
              <check checked="false" name="MISRAC2012-Rule-2.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-3">
              <check checked="true" name="MISRAC2012-Rule-3.1"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-4">
              <check checked="false" name="MISRAC2012-Rule-4.2"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-5">
              <check checked="true" name="MISRAC2012-Rule-5.1"/>
              <check checked="true" name="MISRAC2012-Rule-5.3_a"/>
              <check checked="true" name="MISRAC2012-Rule-5.3_b"/>
              <check checked="true" name="MISRAC2012-Rule-5.3_c"/>
              <check checked="true" name="MISRAC2012-Rule-5.4_c89"/>
              <check checked="true" name="MISRAC2012-Rule-5.4_c99"/>
              <check checked="true" name="MISRAC2012-Rule-5.5_c89"/>
              <check checked="true" name="MISRAC2012-Rule-5.5_c99"/>
              <check checked="true" name="MISRAC2012-Rule-5.6"/>
              <check checked="true" name="MISRAC2012-Rule-5.7"/>
              <check checked="true" name="MISRAC2012-Rule-5.8"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-6">
              <check checked="true" name="MISRAC2012-Rule-6.1"/>
              <check checked="true" name="MISRAC2012-Rule-6.2"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-7">
              <check checked="true" name="MISRAC2012-Rule-7.1"/>
              <check checked="true" name="MISRAC2012-Rule-7.2"/>
              <check checked="true" name="MISRAC2012-Rule-7.3"/>
              <check checked="true" name="MISRAC2012-Rule-7.4_a"/>
              <check checked="true" name="MISRAC2012-Rule-7.4_b"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-8">
              <check checked="true" name="MISRAC2012-Rule-8.1"/>
              <check checked="true" name="MISRAC2012-Rule-8.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-8.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-8.10"/>
              <check checked="false" name="MISRAC2012-Rule-8.11"/>
              <check checked="true" name="MISRAC2012-Rule-8.14"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-9">
              <check checked="true" name="MISRAC2012-Rule-9.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_c"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_d"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_e"/>
              <check checked="true" name="MISRAC2012-Rule-9.1_f"/>
              <check checked="true" name="MISRAC2012-Rule-9.3"/>
              <check checked="true" name="MISRAC2012-Rule-9.5_a"/>
              <check checked="true" name="MISRAC2012-Rule-9.5_b"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-10">
              <check checked="true" name="MISRAC2012-Rule-10.1_R2"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R3"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R4"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R5"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R6"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R7"/>
              <check checked="true" name="MISRAC2012-Rule-10.1_R8"/>
              <check checked="true" name="MISRAC2012-Rule-10.2"/>
              <check checked="true" name="MISRAC2012-Rule-10.3"/>
              <check checked="true" name="MISRAC2012-Rule-10.4"/>
              <check checked="true" name="MISRAC2012-Rule-10.6"/>
              <check checked="true" name="MISRAC2012-Rule-10.7"/>
              <check checked="true" name="MISRAC2012-Rule-10.8"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-11">
              <check checked="true" name="MISRAC2012-Rule-11.1"/>
              <check checked="true" name="MISRAC2012-Rule-11.3"/>
              <check checked="false" name="MISRAC2012-Rule-11.4"/>
              <check checked="true" name="MISRAC2012-Rule-11.7"/>
              <check checked="true" name="MISRAC2012-Rule-11.8"/>
              <check checked="true" name="MISRAC2012-Rule-11.9"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-12">
              <check checked="false" name="MISRAC2012-Rule-12.1"/>
              <check checked="true" name="MISRAC2012-Rule-12.2"/>
              <check checked="false" name="MISRAC2012-Rule-12.3"/>
              <check checked="false" name="MISRAC2012-Rule-12.4"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-13">
              <check checked="true" name="MISRAC2012-Rule-13.1"/>
              <check checked="true" name="MISRAC2012-Rule-13.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-13.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-13.2_c"/>
              <check checked="false" name="MISRAC2012-Rule-13.3"/>
              <check checked="false" name="MISRAC2012-Rule-13.4_a"/>
              <check checked="false" name="MISRAC2012-Rule-13.4_b"/>
              <check checked="true" name="MISRAC2012-Rule-13.5"/>
              <check checked="true" name="MISRAC2012-Rule-13.6"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-14">
              <check checked="true" name="MISRAC2012-Rule-14.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-14.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-14.2"/>
              <check checked="true" name="MISRAC2012-Rule-14.3_a"/>
              <check checked="true" name="MISRAC2012-Rule-14.3_b"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_a"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_b"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_c"/>
              <check checked="true" name="MISRAC2012-Rule-14.4_d"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-15">
              <check checked="false" name="MISRAC2012-Rule-15.1"/>
              <check checked="true" name="MISRAC2012-Rule-15.2"/>
              <check checked="true" name="MISRAC2012-Rule-15.3"/>
              <check checked="false" name="MISRAC2012-Rule-15.4"/>
              <check checked="false" name="MISRAC2012-Rule-15.5"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_a"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_b"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_c"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_d"/>
              <check checked="true" name="MISRAC2012-Rule-15.6_e"/>
              <check checked="true" name="MISRAC2012-Rule-15.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-16">
              <check checked="true" name="MISRAC2012-Rule-16.1"/>
              <check checked="true" name="MISRAC2012-Rule-16.2"/>
              <check checked="true" name="MISRAC2012-Rule-16.3"/>
              <check checked="true" name="MISRAC2012-Rule-16.4"/>
              <check checked="true" name="MISRAC2012-Rule-16.5"/>
              <check checked="true" name="MISRAC2012-Rule-16.6"/>
              <check checked="true" name="MISRAC2012-Rule-16.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-17">
              <check checked="true" name="MISRAC2012-Rule-17.1"/>
              <check checked="true" name="MISRAC2012-Rule-17.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-17.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-17.3"/>
              <check checked="true" name="MISRAC2012-Rule-17.4"/>
              <check checked="true" name="MISRAC2012-Rule-17.6"/>
              <check checked="true" name="MISRAC2012-Rule-17.7"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-18">
              <check checked="true" name="MISRAC2012-Rule-18.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-18.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-18.1_c"/>
              <check checked="true" name="MISRAC2012-Rule-18.1_d"/>
              <check checked="false" name="MISRAC2012-Rule-18.5"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_a"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_b"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_c"/>
              <check checked="true" name="MISRAC2012-Rule-18.6_d"/>
              <check checked="true" name="MISRAC2012-Rule-18.7"/>
              <check checked="true" name="MISRAC2012-Rule-18.8"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-19">
              <check checked="true" name="MISRAC2012-Rule-19.1"/>
              <check checked="false" name="MISRAC2012-Rule-19.2"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-20">
              <check checked="true" name="MISRAC2012-Rule-20.2"/>
              <check checked="true" name="MISRAC2012-Rule-20.4_c89"/>
              <check checked="true" name="MISRAC2012-Rule-20.4_c99"/>
              <check checked="false" name="MISRAC2012-Rule-20.5"/>
              <check checked="false" name="MISRAC2012-Rule-20.10"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-21">
              <check checked="true" name="MISRAC2012-Rule-21.1"/>
              <check checked="true" name="MISRAC2012-Rule-21.2"/>
              <check checked="true" name="MISRAC2012-Rule-21.3"/>
              <check checked="true" name="MISRAC2012-Rule-21.4"/>
              <check checked="true" name="MISRAC2012-Rule-21.5"/>
              <check checked="true" name="MISRAC2012-Rule-21.6"/>
              <check checked="true" name="MISRAC2012-Rule-21.7"/>
              <check checked="true" name="MISRAC2012-Rule-21.8"/>
              <check checked="true" name="MISRAC2012-Rule-21.9"/>
              <check checked="true" name="MISRAC2012-Rule-21.10"/>
              <check checked="true" name="MISRAC2012-Rule-21.11"/>
            </group>
            <group checked="true" name="MISRAC2012-Rule-22">
              <check checked="true" name="MISRAC2012-Rule-22.1_a"/>
              <check checked="true" name="MISRAC2012-Rule-22.1_b"/>
              <check checked="true" name="MISRAC2012-Rule-22.2_a"/>
              <check checked="true" name="MISRAC2012-Rule-22.2_b"/>
              <check checked="true" name="MISRAC2012-Rule-22.2_c"/>
              <check checked="true" name="MISRAC2012-Rule-22.4"/>
              <check checked="true" name="MISRAC2012-Rule-22.5_a"/>
              <check checked="true" name="MISRAC2012-Rule-22.5_b"/>
              <check checked="true" name="MISRAC2012-Rule-22.6"/>
            </group>
          </package>
          <package checked="false" name="MISRAC++2008">
            <group checked="true" name="MISRAC++2008-0-1">
              <check checked="true" name="MISRAC++2008-0-1-1"/>
              <check checked="true" name="MISRAC++2008-0-1-2_a"/>
              <check checked="true" name="MISRAC++2008-0-1-2_b"/>
              <check checked="true" name="MISRAC++2008-0-1-2_c"/>
              <check checked="true" name="MISRAC++2008-0-1-3"/>
              <check checked="true" name="MISRAC++2008-0-1-4"/>
              <check checked="true" name="MISRAC++2008-0-1-6"/>
              <check checked="true" name="MISRAC++2008-0-1-7"/>
              <check checked="false" name="MISRAC++2008-0-1-8"/>
              <check checked="true" name="MISRAC++2008-0-1-9"/>
              <check checked="true" name="MISRAC++2008-0-1-11"/>
            </group>
            <group checked="true" name="MISRAC++2008-0-2">
              <check checked="true" name="MISRAC++2008-0-2-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-0-3">
              <check checked="true" name="MISRAC++2008-0-3-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-3">
              <check checked="true" name="MISRAC++2008-2-3-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-7">
              <check checked="true" name="MISRAC++2008-2-7-1"/>
              <check checked="true" name="MISRAC++2008-2-7-2"/>
              <check checked="false" name="MISRAC++2008-2-7-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-10">
              <check checked="true" name="MISRAC++2008-2-10-2_a"/>
              <check checked="true" name="MISRAC++2008-2-10-2_b"/>
              <check checked="true" name="MISRAC++2008-2-10-2_c"/>
              <check checked="true" name="MISRAC++2008-2-10-2_d"/>
              <check checked="true" name="MISRAC++2008-2-10-3"/>
              <check checked="true" name="MISRAC++2008-2-10-4"/>
              <check checked="false" name="MISRAC++2008-2-10-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-2-13">
              <check checked="true" name="MISRAC++2008-2-13-2"/>
              <check checked="true" name="MISRAC++2008-2-13-3"/>
              <check checked="true" name="MISRAC++2008-2-13-4_a"/>
              <check checked="true" name="MISRAC++2008-2-13-4_b"/>
            </group>
            <group checked="true" name="MISRAC++2008-3-1">
              <check checked="true" name="MISRAC++2008-3-1-1"/>
              <check checked="true" name="MISRAC++2008-3-1-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-3-9">
              <check checked="false" name="MISRAC++2008-3-9-2"/>
              <check checked="true" name="MISRAC++2008-3-9-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-4-5">
              <check checked="true" name="MISRAC++2008-4-5-1"/>
              <check checked="true" name="MISRAC++2008-4-5-2"/>
              <check checked="true" name="MISRAC++2008-4-5-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-0">
              <check checked="true" name="MISRAC++2008-5-0-1_a"/>
              <check checked="true" name="MISRAC++2008-5-0-1_b"/>
              <check checked="true" name="MISRAC++2008-5-0-1_c"/>
              <check checked="false" name="MISRAC++2008-5-0-2"/>
              <check checked="true" name="MISRAC++2008-5-0-3"/>
              <check checked="true" name="MISRAC++2008-5-0-4"/>
              <check checked="true" name="MISRAC++2008-5-0-5"/>
              <check checked="true" name="MISRAC++2008-5-0-6"/>
              <check checked="true" name="MISRAC++2008-5-0-7"/>
              <check checked="true" name="MISRAC++2008-5-0-8"/>
              <check checked="true" name="MISRAC++2008-5-0-9"/>
              <check checked="true" name="MISRAC++2008-5-0-10"/>
              <check checked="true" name="MISRAC++2008-5-0-13_a"/>
              <check checked="true" name="MISRAC++2008-5-0-13_b"/>
              <check checked="true" name="MISRAC++2008-5-0-13_c"/>
              <check checked="true" name="MISRAC++2008-5-0-13_d"/>
              <check checked="true" name="MISRAC++2008-5-0-14"/>
              <check checked="true" name="MISRAC++2008-5-0-15_a"/>
              <check checked="true" name="MISRAC++2008-5-0-15_b"/>
              <check checked="true" name="MISRAC++2008-5-0-16_a"/>
              <check checked="true" name="MISRAC++2008-5-0-16_b"/>
              <check checked="true" name="MISRAC++2008-5-0-16_c"/>
              <check checked="true" name="MISRAC++2008-5-0-16_d"/>
              <check checked="true" name="MISRAC++2008-5-0-16_e"/>
              <check checked="true" name="MISRAC++2008-5-0-16_f"/>
              <check checked="true" name="MISRAC++2008-5-0-19"/>
              <check checked="true" name="MISRAC++2008-5-0-21"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-2">
              <check checked="true" name="MISRAC++2008-5-2-4"/>
              <check checked="true" name="MISRAC++2008-5-2-5"/>
              <check checked="true" name="MISRAC++2008-5-2-6"/>
              <check checked="true" name="MISRAC++2008-5-2-7"/>
              <check checked="false" name="MISRAC++2008-5-2-9"/>
              <check checked="false" name="MISRAC++2008-5-2-10"/>
              <check checked="true" name="MISRAC++2008-5-2-11_a"/>
              <check checked="true" name="MISRAC++2008-5-2-11_b"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-3">
              <check checked="true" name="MISRAC++2008-5-3-1"/>
              <check checked="true" name="MISRAC++2008-5-3-2_a"/>
              <check checked="true" name="MISRAC++2008-5-3-2_b"/>
              <check checked="true" name="MISRAC++2008-5-3-3"/>
              <check checked="true" name="MISRAC++2008-5-3-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-8">
              <check checked="true" name="MISRAC++2008-5-8-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-14">
              <check checked="true" name="MISRAC++2008-5-14-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-18">
              <check checked="true" name="MISRAC++2008-5-18-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-5-19">
              <check checked="false" name="MISRAC++2008-5-19-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-2">
              <check checked="true" name="MISRAC++2008-6-2-1"/>
              <check checked="true" name="MISRAC++2008-6-2-2"/>
              <check checked="true" name="MISRAC++2008-6-2-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-3">
              <check checked="true" name="MISRAC++2008-6-3-1_a"/>
              <check checked="true" name="MISRAC++2008-6-3-1_b"/>
              <check checked="true" name="MISRAC++2008-6-3-1_c"/>
              <check checked="true" name="MISRAC++2008-6-3-1_d"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-4">
              <check checked="true" name="MISRAC++2008-6-4-1"/>
              <check checked="true" name="MISRAC++2008-6-4-2"/>
              <check checked="true" name="MISRAC++2008-6-4-3"/>
              <check checked="true" name="MISRAC++2008-6-4-4"/>
              <check checked="true" name="MISRAC++2008-6-4-5"/>
              <check checked="true" name="MISRAC++2008-6-4-6"/>
              <check checked="true" name="MISRAC++2008-6-4-7"/>
              <check checked="true" name="MISRAC++2008-6-4-8"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-5">
              <check checked="true" name="MISRAC++2008-6-5-1_a"/>
              <check checked="true" name="MISRAC++2008-6-5-2"/>
              <check checked="true" name="MISRAC++2008-6-5-3"/>
              <check checked="true" name="MISRAC++2008-6-5-4"/>
              <check checked="true" name="MISRAC++2008-6-5-6"/>
            </group>
            <group checked="true" name="MISRAC++2008-6-6">
              <check checked="true" name="MISRAC++2008-6-6-1"/>
              <check checked="true" name="MISRAC++2008-6-6-2"/>
              <check checked="true" name="MISRAC++2008-6-6-4"/>
              <check checked="true" name="MISRAC++2008-6-6-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-1">
              <check checked="true" name="MISRAC++2008-7-1-1"/>
              <check checked="true" name="MISRAC++2008-7-1-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-2">
              <check checked="true" name="MISRAC++2008-7-2-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-4">
              <check checked="true" name="MISRAC++2008-7-4-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-7-5">
              <check checked="true" name="MISRAC++2008-7-5-1_a"/>
              <check checked="true" name="MISRAC++2008-7-5-1_b"/>
              <check checked="true" name="MISRAC++2008-7-5-2_a"/>
              <check checked="true" name="MISRAC++2008-7-5-2_b"/>
              <check checked="true" name="MISRAC++2008-7-5-2_c"/>
              <check checked="true" name="MISRAC++2008-7-5-2_d"/>
              <check checked="false" name="MISRAC++2008-7-5-4_a"/>
              <check checked="false" name="MISRAC++2008-7-5-4_b"/>
            </group>
            <group checked="true" name="MISRAC++2008-8-0">
              <check checked="true" name="MISRAC++2008-8-0-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-8-4">
              <check checked="true" name="MISRAC++2008-8-4-1"/>
              <check checked="true" name="MISRAC++2008-8-4-3"/>
              <check checked="true" name="MISRAC++2008-8-4-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-8-5">
              <check checked="true" name="MISRAC++2008-8-5-1_a"/>
              <check checked="true" name="MISRAC++2008-8-5-1_b"/>
              <check checked="true" name="MISRAC++2008-8-5-1_c"/>
              <check checked="true" name="MISRAC++2008-8-5-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-9-3">
              <check checked="true" name="MISRAC++2008-9-3-1"/>
              <check checked="true" name="MISRAC++2008-9-3-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-9-5">
              <check checked="true" name="MISRAC++2008-9-5-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-9-6">
              <check checked="true" name="MISRAC++2008-9-6-2"/>
              <check checked="true" name="MISRAC++2008-9-6-3"/>
              <check checked="true" name="MISRAC++2008-9-6-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-12-1">
              <check checked="true" name="MISRAC++2008-12-1-1_a"/>
              <check checked="true" name="MISRAC++2008-12-1-1_b"/>
              <check checked="true" name="MISRAC++2008-12-1-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-0">
              <check checked="false" name="MISRAC++2008-15-0-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-1">
              <check checked="true" name="MISRAC++2008-15-1-2"/>
              <check checked="true" name="MISRAC++2008-15-1-3"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-3">
              <check checked="true" name="MISRAC++2008-15-3-1"/>
              <check checked="false" name="MISRAC++2008-15-3-2"/>
              <check checked="true" name="MISRAC++2008-15-3-3"/>
              <check checked="true" name="MISRAC++2008-15-3-4"/>
              <check checked="true" name="MISRAC++2008-15-3-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-15-5">
              <check checked="true" name="MISRAC++2008-15-5-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-16-0">
              <check checked="true" name="MISRAC++2008-16-0-3"/>
              <check checked="true" name="MISRAC++2008-16-0-4"/>
            </group>
            <group checked="true" name="MISRAC++2008-16-2">
              <check checked="true" name="MISRAC++2008-16-2-2"/>
              <check checked="true" name="MISRAC++2008-16-2-3"/>
              <check checked="true" name="MISRAC++2008-16-2-4"/>
              <check checked="false" name="MISRAC++2008-16-2-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-16-3">
              <check checked="true" name="MISRAC++2008-16-3-1"/>
              <check checked="false" name="MISRAC++2008-16-3-2"/>
            </group>
            <group checked="true" name="MISRAC++2008-17-0">
              <check checked="true" name="MISRAC++2008-17-0-1"/>
              <check checked="true" name="MISRAC++2008-17-0-3"/>
              <check checked="true" name="MISRAC++2008-17-0-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-0">
              <check checked="true" name="MISRAC++2008-18-0-1"/>
              <check checked="true" name="MISRAC++2008-18-0-2"/>
              <check checked="true" name="MISRAC++2008-18-0-3"/>
              <check checked="true" name="MISRAC++2008-18-0-4"/>
              <check checked="true" name="MISRAC++2008-18-0-5"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-2">
              <check checked="true" name="MISRAC++2008-18-2-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-4">
              <check checked="true" name="MISRAC++2008-18-4-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-18-7">
              <check checked="true" name="MISRAC++2008-18-7-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-19-3">
              <check checked="true" name="MISRAC++2008-19-3-1"/>
            </group>
            <group checked="true" name="MISRAC++2008-27-0">
              <check checked="true" name="MISRAC++2008-27-0-1"/>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include\stm32f2xx.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include\system_stm32f2xx.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Source\Templates\system_stm32f2xx.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Linker</name>
    <file>
      <name>$PROJ_DIR$\..\stm32f2xx_flash.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f2xx_flash_extsram.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f2xx_sram.icf</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Source\Templates\iar\startup_stm32f2xx.s</name>
    </file>
  </group>
  <group>
    <name>STM_Periph_Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_syscfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc\stm32f2xx_usart.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
    </group>
  </group>
  <group>
    <name>SystemView</name>
    <group>
      <name>Config</name>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\Config\Global.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\Config\SEGGER_RTT_Conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\Config\SEGGER_SYSVIEW_Conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\Config\SEGGER_SYSVIEW_Config_NoOS.c</name>
      </file>
    </group>
    <group>
      <name>OS</name>
    </group>
    <group>
      <name>SEGGER</name>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER_RTT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER_RTT.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER_SYSVIEW.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER_SYSVIEW.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER_SYSVIEW_ConfDefaults.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\SystemView\SEGGER\SEGGER_SYSVIEW_Int.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>USB Device</name>
    <group>
      <name>Class</name>
      <group>
        <name>CDC</name>
        <group>
          <name>inc</name>
          <file>
            <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc\usbd_cdc_core.h</name>
          </file>
        </group>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Class\cdc\src\usbd_cdc_core.c</name>
            <configuration>
              <name>Flash-Debug</name>
            </configuration>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>Library</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\inc\usbd_core.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\inc\usbd_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\inc\usbd_ioreq.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\inc\usbd_req.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\inc\usbd_usr.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_core.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_ioreq.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_req.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>USB Driver</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\inc\usb_bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\inc\usb_core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\inc\usb_dcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\inc\usb_dcd_int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\inc\usb_defines.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\inc\usb_regs.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_core.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_dcd.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_dcd_int.c</name>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </file>
    </group>
  </group>
  <group>
    <name>user</name>
    <group>
      <name>inc</name>
      <group>
        <name>EEPROM_RTC</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_eeprom_rtc.h</name>
        </file>
      </group>
      <group>
        <name>FSMC</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_fsmc.h</name>
        </file>
      </group>
      <group>
        <name>general</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_global.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_septoints_interval.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_settings.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\constants.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\functions_external.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\functions_global.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\header.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\libraries.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\macroses.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\type_definition.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\variables_external.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\variables_global.h</name>
        </file>
      </group>
      <group>
        <name>interfaces</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_interfaces.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_modbus_memory_map.h</name>
        </file>
      </group>
      <group>
        <name>menu</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_lcd_and_keyboard.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_alarm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_choose_communication_parameters.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_choose_settings_logical_nodes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_configuration.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_diagnostyka.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_group_alarm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_info.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_input.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_labels.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_list_settings.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_list_settings_bios.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_main.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_meander.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_measurement.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_output_led.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_param_list_logical_nodes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_password.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_registrators.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_setting_language.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_state_inputs_outputs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_time.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu2_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_menu_ver2.h</name>
        </file>
      </group>
      <group>
        <name>microcontriller</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\hw_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\platform_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\stm32f2xx_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\stm32f2xx_it.h</name>
        </file>
      </group>
      <group>
        <name>protection</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_df.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_global_timers.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_koef_povernennja.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_measurement.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_watchdog.h</name>
        </file>
      </group>
      <group>
        <name>Serial Dataflash</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\const_driver_serial_dataflash.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>src</name>
      <group>
        <name>EEPROM_RTC</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\eeprom_rtc.c</name>
        </file>
      </group>
      <group>
        <name>FSMC</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\fsmc_sram.c</name>
        </file>
      </group>
      <group>
        <name>general</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\v_A_shm\low_level_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\procedures.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\start_settings.c</name>
        </file>
      </group>
      <group>
        <name>interfaces</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\interfaces.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\modbus.c</name>
        </file>
      </group>
      <group>
        <name>interrupts</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\interrupts.c</name>
        </file>
      </group>
      <group>
        <name>menu</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\driver_lcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_alarm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_choose_communication_parameters.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_choose_settings_logical_nodes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_configuration.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_diagnostyka.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_group_alarm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_info.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_input.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_labels.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_level_password.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_list_logical_nodes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_list_settings.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_list_settings_bios.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_meander.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_output_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_param_list_logical_nodes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_registrators.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_setting_language.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_state_inputs_outputs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\inc\menu_ver2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\menu_view_measurement.c</name>
        </file>
      </group>
      <group>
        <name>microcontroller</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\hw_config.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\stm32f2xx_it.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
      </group>
      <group>
        <name>protection</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\measurement.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\protections.c</name>
        </file>
      </group>
      <group>
        <name>Serial Dataflash</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\src\driver_serial_dataflash.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>usb</name>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usb_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usbd_cdc_vcp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usbd_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usbd_desc.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usb_bsp.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usbd_cdc_vcp.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usbd_desc.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\usb\usbd_usr.c</name>
          <configuration>
            <name>Flash-Debug</name>
          </configuration>
        </file>
      </group>
    </group>
    <group>
      <name>v_A_shm</name>
      <group>
        <name>v_A_shm_C</name>
        <file>
          <name>$PROJ_DIR$\..\..\working files\v_A_shm\I_Shm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\working files\v_A_shm\prtTmr.c</name>
        </file>
        <configuration>
          <name>Flash-Debug</name>
        </configuration>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\andstng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\BaseInPoint.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\BaseInPoint.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\ExtPoint.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\InPoint.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUAlt.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUAnd_8_1.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUBase.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUBase.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUBGS.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUDInput_0_1.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUDout_1_0.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUDout_1_0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LULed.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUNot_1_1.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUOr_8_1.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\LUXor_8_1.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\Mft.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\prtTmr.hpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\Shematic.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\working files\v_A_shm\Shematic.h</name>
      </file>
      <configuration>
        <name>Flash-Debug</name>
      </configuration>
    </group>
  </group>
</project>


